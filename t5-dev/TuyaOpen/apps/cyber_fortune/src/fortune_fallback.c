/**
 * @file fortune_fallback.c
 * @brief Pre-written local lots, one per category × grade. Style matches the
 *        backend prompt: vernacular 4-line poem + targeted explanation +
 *        actionable advice. All text stays inside GB2312.
 */

#include <string.h>
#include <stdio.h>

#include "fortune_fallback.h"

#include "tal_api.h"

typedef struct {
    const char *poem[4];
    const char *explanation;
    const char *advice;
} fallback_text_t;

/* grade order: 0=上上 1=上 2=中 3=下 4=下下 (same as backend) */
static const char *const GRADE_NAMES[5] = {"上上", "上", "中", "下", "下下"};
static const int GRADE_SCORES[5] = {5, 4, 3, 2, 1};
/* weights 15/30/35/15/5 → cumulative thresholds over 100 */
static const int GRADE_CUM[5] = {15, 45, 80, 95, 100};

/* --- 财运 --- */
static const fallback_text_t FB_WEALTH[5] = {
    {{"财门今日为你开", "正财偏财一起来", "只管放手去争取", "钱包眼看鼓起来"},
     "财运正旺，之前埋下的种子开始结果，无论工资、副业还是投资，都有看得见的进账机会。",
     "该谈的报酬大胆谈，该收的钱及时收，但记得留三分本金傍身。"},
    {{"手里活钱渐渐多", "稳扎稳打不用愁", "机会来时接得住", "小富靠攒不靠博"},
     "财运向好，收入稳中有升，近期会有一个不大不小的进财机会，抓住了就是一笔踏实的收获。",
     "先把日常开销理清楚，再拿闲钱做打算，不熟悉的领域少碰。"},
    {{"钱来钱去平常事", "不多不少刚刚好", "省下一笔是一笔", "细水长流最可靠"},
     "财运平平，进出基本持平，发不了横财也破不了大财，是攒基本盘的好时候。",
     "管住冲动消费，记一记账，年底回头看你会感谢现在的自己。"},
    {{"钱袋近来有点松", "东漏西漏不知踪", "捂紧口袋莫着急", "过了这阵又一冬"},
     "近期财运偏弱，容易有计划外的开销，投资决策也容易看走眼，不宜进行大额操作。",
     "大额支出缓一缓，借钱担保要三思，守住现有的就是赢。"},
    {{"财路一时雾蒙蒙", "越是心急越扑空", "停下脚步歇一歇", "雾散自然见彩虹"},
     "财运低迷，越想快速回本越容易掉坑，此时任何听起来稳赚不赔的路子都要打个问号。",
     "现金为王，什么都别投，把精力放回主业，等这阵子过去再说。"},
};

/* --- 事业 --- */
static const fallback_text_t FB_CAREER[5] = {
    {{"东风正劲好扬帆", "贵人抬手路更宽", "台上台下都看你", "此时不上待何年"},
     "事业运极佳，你的努力正被关键的人看在眼里，升职、跳槽或新项目都容易得到支持。",
     "主动争取露脸的机会，把想法讲出来，这阵风口别客气。"},
    {{"一步一个脚印深", "手上功夫渐渐纯", "眼前虽无大动静", "暗中已被记一功"},
     "事业稳步上行，虽然暂时没有大的突破，但你的靠谱正在积累口碑，机会在悄悄靠近。",
     "把手头的事做到超出预期一点点，别催结果，果子熟了自然落。"},
    {{"不好不坏平平过", "按部就班少差错", "骑驴看唱本走着瞧", "机会还在后头呢"},
     "事业运平稳，不温不火，适合打磨技能、理顺关系，为下一波行情做准备。",
     "与其焦虑不如学点新东西，半年后的你会用得上。"},
    {{"路上碎石有点多", "推进难免受折磨", "放慢脚步看清路", "绕过去了就是坡"},
     "近期工作阻力偏大，容易遇到推诿、返工或临时变卦，硬顶容易两败俱伤。",
     "重要事情留好文字记录，少站队少表态，稳住基本盘。"},
    {{"逆风行船莫强撑", "帆破再补也不迟", "退一步来天地宽", "留得青山有柴烧"},
     "事业运低谷，此时冲动跳槽、硬刚上级或仓促创业都容易踩坑，宜守不宜攻。",
     "把这段当蓄力期，健身读书攒本事，风向一转你就是先起飞的那个。"},
};

/* --- 姻缘 --- */
static const fallback_text_t FB_LOVE[5] = {
    {{"桃花朵朵开满枝", "有心之人正当时", "眼神对上别装傻", "月老红线已牵好"},
     "姻缘运大旺，单身的人身边正有人对你有意，有伴的感情也会更进一步，是表白和承诺的好时机。",
     "别端着，主动一点，一句真心话胜过十次欲言又止。"},
    {{"春水微澜起涟漪", "缘分悄悄靠近你", "多出门来多见人", "好事多半在路上"},
     "感情运向好，多参加聚会走动，容易遇到聊得来的人；有伴者多制造两人时光，感情升温。",
     "收拾好自己，把周末排出去，缘分不会敲宅家的门。"},
    {{"感情如水淡淡流", "不咸不淡不用愁", "陪伴本是长情事", "平平淡淡才是真"},
     "感情运平稳，没有大惊喜也没有大风波，关系的深浅取决于你愿意投入多少。",
     "少刷手机多说话，一起吃顿好饭，比什么仪式感都实在。"},
    {{"雾里看花花非花", "心里打鼓别装傻", "话不说开结难解", "开诚布公是一家"},
     "感情运偏弱，容易因误会、猜疑或沟通不畅起摩擦，暧昧关系也容易停滞不前。",
     "有话当面说，别让第三个人传话，也别在气头上做决定。"},
    {{"风雨敲窗心事重", "强求的果不会甜", "先把自己活明白", "缘去缘来皆是缘"},
     "感情运低迷，勉强维系或强行开始都容易受伤，此刻更需要把重心放回自己身上。",
     "该放下的体面放下，去健身去旅行，状态好了，对的人才认得出你。"},
};

/* --- 学业 --- */
static const fallback_text_t FB_STUDY[5] = {
    {{"文昌星照读书郎", "过目不忘状态强", "考场笔下如有神", "金榜题名理应当"},
     "学业运极佳，理解力和记忆力都在线，之前的积累开始融会贯通，大考小考都容易超常发挥。",
     "趁状态好啃最硬的骨头，错题本再过一遍，稳稳收割。"},
    {{"灯下功夫不白费", "一分耕耘一分对", "难关渐渐有松动", "再加把劲见光辉"},
     "学业运向好，努力开始见效，成绩曲线稳步上扬，坚持现在的节奏就能看到明显进步。",
     "保持节奏别熬大夜，睡够了脑子才转得快。"},
    {{"书山有路慢慢爬", "不快不慢也到家", "基础打牢是正道", "厚积薄发靠大家"},
     "学业运平平，没有开挂也没有掉队，此时拼的是基本功和坐得住的功夫。",
     "少刷短视频，把整块时间留给最重要的科目。"},
    {{"心浮气躁书难进", "看了半天记不清", "先把心思收回来", "一页一页慢慢行"},
     "近期学习状态偏差，容易分心走神，效率不高，越焦虑越学不进去。",
     "把大目标切成小块，学四十分钟休息十分钟，先找回手感。"},
    {{"迷雾遮眼路难寻", "越急越乱越糟心", "不如停笔理思路", "磨刀不误砍柴工"},
     "学业运低谷，可能遇到瓶颈期或重要考试失利，此时自我否定是最大的敌人。",
     "允许自己缓两天，然后找老师或同学复盘，方法比蛮力重要。"},
};

/* --- 健康 --- */
static const fallback_text_t FB_HEALTH[5] = {
    {{"气血充盈精神爽", "步履轻快身体棒", "吃嘛嘛香睡得沉", "百病见你绕道躺"},
     "健康运极佳，精力充沛状态在线，是养成好习惯、提升体能的黄金窗口。",
     "趁状态好把运动习惯立起来，每周三次，一年后判若两人。"},
    {{"身子骨儿渐硬朗", "旧疾小恙慢慢好", "规律作息加锻炼", "健康账户在上涨"},
     "健康运向好，之前的小毛病在好转，坚持规律作息会让状态更上一层楼。",
     "睡前放下手机，多喝温水多走路，身体会给你回报。"},
    {{"无病无灾平安过", "小累小乏难免有", "劳逸结合心放宽", "平安就是大福气"},
     "健康运平稳，没有大问题，但久坐、熬夜这些小账正在悄悄累积。",
     "每小时起来动一动，晚上十二点前睡，别透支明天。"},
    {{"身体近来敲警钟", "腰酸背痛提醒中", "小恙莫拖成大患", "早查早治早轻松"},
     "近期健康运偏弱，容易疲劳、失眠或旧疾反复，身体在向你要休息。",
     "不舒服别硬扛，该检查检查，该请假请假，身体是本钱。"},
    {{"油灯将尽莫再熬", "身体报警要知道", "放下手里千般事", "好好睡觉最重要"},
     "健康运低迷，长期透支的疲惫可能集中爆发，此时任何事都没有休息重要。",
     "立刻调整作息，安排一次体检，把健康排在日程第一位。"},
};

/* --- 今日运势 --- */
static const fallback_text_t FB_TODAY[5] = {
    {{"今日出门捡到宝", "事事顺心步步高", "贵人微笑迎面来", "好运挡都挡不住"},
     "今天运势大好，做事顺畅，容易遇到帮你一把的人，适合办要紧事、见重要的人。",
     "把拖了很久的那件事今天办了，趁手气正顺。"},
    {{"晨光透窗心情好", "小事顺利烦恼少", "该出手时就出手", "今天适合往前跑"},
     "今日运势不错，推进事情比平时省力，小惊喜可能藏在日常里。",
     "列个三件事清单，逐个划掉，晚上给自己点个赞。"},
    {{"日子平平也是福", "不惊不喜稳当过", "手头事情按序做", "晚来一觉睡得足"},
     "今天运势平平，按部就班最稳妥，不适合冒险也无需担心。",
     "专注眼前事，少凑热闹，平稳收工就是胜利。"},
    {{"今日诸事有点黏", "磕磕绊绊费点劲", "凡事慢半拍再做", "耐心就是护身符"},
     "今天容易遇到小堵点：迟到、误会、丢三落四，越急越乱。",
     "出门多留十分钟，重要的话发之前多读一遍。"},
    {{"乌云压顶别出招", "今天宜静不宜躁", "是非口舌绕道走", "早点回家睡大觉"},
     "今日运势低迷，容易踩坑背锅，重大决定和激烈争论都不适合今天。",
     "能推的局就推掉，早点休息，明天又是新的一天。"},
};

static const fallback_text_t *const FB_BY_CAT[FORTUNE_CAT_COUNT] = {
    FB_WEALTH, FB_CAREER, FB_LOVE, FB_STUDY, FB_HEALTH, FB_TODAY,
};

static int draw_grade_index(void)
{
    int roll = tal_system_get_random(100);
    for (int i = 0; i < 5; i++) {
        if (roll < GRADE_CUM[i]) {
            return i;
        }
    }
    return 2; /* 中 */
}

static void copy_str(char *dst, size_t dst_size, const char *src)
{
    strncpy(dst, src, dst_size - 1);
    dst[dst_size - 1] = '\0';
}

void fortune_fallback_get(fortune_category_t cat, fortune_result_t *out)
{
    if (out == NULL) {
        return;
    }
    if (cat >= FORTUNE_CAT_COUNT) {
        cat = FORTUNE_CAT_TODAY;
    }

    int g = draw_grade_index();
    const fallback_text_t *txt = &FB_BY_CAT[cat][g];

    memset(out, 0, sizeof(*out));
    out->lot_no = 1 + tal_system_get_random(100);
    out->grade_score = GRADE_SCORES[g];
    copy_str(out->grade, sizeof(out->grade), GRADE_NAMES[g]);
    for (int i = 0; i < 4; i++) {
        copy_str(out->poem[i], sizeof(out->poem[i]), txt->poem[i]);
    }
    copy_str(out->explanation, sizeof(out->explanation), txt->explanation);
    copy_str(out->advice, sizeof(out->advice), txt->advice);
}
